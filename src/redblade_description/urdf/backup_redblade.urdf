Commit message: Reorganized redblade repo

File: src/redblade_description/urdf/backup_redblade.urdf (robot description, URDF)
Before this commit: robot redblade, 62 links, 61 joints
Links:
- link base_link: geometry visual box size=0.025 0.35 0.025
